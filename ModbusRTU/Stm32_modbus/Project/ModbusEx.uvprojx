# Keil uVision project ModbusEx.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ModbusEx +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\App\modbus_slave;..\App\register_map;..\App\surge_scenario;..\Drivers\BSP;..\Drivers\CMSIS\startup;..\Drivers\FWlib\inc;..\Drivers\CMSIS;..\App
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ../App/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group STARTUP
    ../Drivers/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../Drivers/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLib
    ../Drivers/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group BSP
    ../Drivers/BSP/: bsp_led.c bsp_pwm.c bsp_rs485.c bsp_sys.c
  group modbus_slave
    ../App/modbus_slave/: modbus_crc.c modbus_crc.h modbus_slave.c modbus_slave.h
  group register_map
    ../App/register_map/: register_map.c register_map.h
